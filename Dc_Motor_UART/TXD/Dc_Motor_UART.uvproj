# Keil uVision project Dc_Motor_UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Dc_Motor_UART +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Dc_Motor_UART.c delay.c delay.h uart.c uart.h TXD.txt
